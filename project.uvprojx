# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread.elf
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32F103xE
  c include: applications\ali-link-sdk\LinkSDK\components\subdev;applications\ali-link-sdk\LinkSDK\core\sysdep;applications\ali-link-sdk\LinkSDK\core\utils;applications\ali-link-sdk\LinkSDK\core;applications;.;rt-thread\components\net\at\include;rt-thread\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\esp8266;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\nogcc;rt-thread\components\libc\mmap;rt-thread\components\libc\pthreads;libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;libraries\STM32F1xx_HAL\CMSIS\Include;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\socket\sys_socket;rt-thread\components\utilities\ulog
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group ali_link_sdk
    applications/ali-link-sdk/LinkSDK/core/: aiot_state_api.c aiot_coap_api.c aiot_http_api.c core_aes.c aiot_mqtt_api.c
    applications/ali-link-sdk/LinkSDK/core/sysdep/: core_sysdep.c core_adapter.c
    applications/ali-link-sdk/LinkSDK/core/utils/: core_auth.c core_global.c core_http.c core_sha256.c core_diag.c core_string.c core_log.c
    applications/ali-link-sdk/LinkSDK/external/: ali_ca_cert.c
    applications/ali-link-sdk/LinkSDK/components/subdev/: cJSON.c aiot_subdev_api.c
    applications/ali-link-sdk/LinkSDK/portfiles/aiot_port/: rtthread_port.c
  group Applications
    applications/: mqtt_tx.c main.c mqtt_subdev.c zigbee_rx.c
    applications/ali-link-sdk/LinkSDK/core/: aiot_state_api.c aiot_coap_api.c aiot_http_api.c core_aes.c aiot_mqtt_api.c
    applications/ali-link-sdk/LinkSDK/core/sysdep/: core_sysdep.c core_adapter.c
    applications/ali-link-sdk/LinkSDK/core/utils/: core_auth.c core_global.c core_http.c core_sha256.c core_diag.c core_string.c core_log.c
    applications/ali-link-sdk/LinkSDK/external/: ali_ca_cert.c
    applications/ali-link-sdk/LinkSDK/components/subdev/: cJSON.c aiot_subdev_api.c
    applications/ali-link-sdk/LinkSDK/portfiles/aiot_port/: rtthread_port.c
  group AT
    rt-thread/components/net/at/at_socket/: at_socket.c
    rt-thread/components/net/at/src/: at_client.c at_utils.c at_cli.c
  group at_device
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/rtc/: soft_rtc.c rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: dataqueue.c waitqueue.c workqueue.c completion.c ringblk_buf.c pipe.c ringbuffer.c
  group Drivers
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    rt-thread/src/: mem.c ipc.c device.c irq.c thread.c timer.c mempool.c clock.c scheduler.c object.c idle.c kservice.c memheap.c components.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: stdio.c mem_std.c libc.c syscalls.c
    rt-thread/components/libc/compilers/common/: time.c unistd.c stdlib.c delay.c
    rt-thread/components/libc/mmap/: posix_mmap.c
    rt-thread/components/libc/pthreads/: mqueue.c pthread.c pthread_barrier.c pthread_cond.c pthread_attr.c semaphore.c pthread_tls.c pthread_mutex.c pthread_spin.c sched.c pthread_rwlock.c
  group Libraries
    libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/impl/: af_inet_at.c
    rt-thread/components/net/sal_socket/socket/: net_sockets.c net_netdb.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c

# Keil uVision project L476.uvprojx, settings and files
target L476 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: L476 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx,__TARGET_FPU_VFP,ARM_MATH_CM4,__FPU_PRESENT,__CC_ARM
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\..\..;..\..\..\at;..\..\..\..\..\core\sysdep;..\..\..\..\..\core;..\..\..\..\..\core\sysdep;..\..\..\..\..\core\utils;..\..\..\..\..\external\mbedtls\include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32l4xx_it.c stm32l4xx_hal_msp.c
    ../Core/: hal_adapter.c mqtt_at_basic_demo.c os_freertos_impl.c utils.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Linkkit/core
    ../../../../../core/: aiot_mqtt_api.c aiot_state_api.c
    ../../../../../core/utils/: core_auth.c core_diag.c core_global.c core_http.c core_log.c core_sha256.c core_string.c
    ../../../../../core/sysdep/: core_adapter.c core_sysdep.c
  group Linkkit/porfiles/at_port
    ../../../: at_port.c
    ../../../at/: aiot_at_api.c net_at_impl.c
    ../../../at/module/: air724_ssl.c air724_tcp.c fibcom_l610_ssl.c fibcom_l610_tcp.c quectel_ec200s_ssl.c quectel_ec200s_tcp.c
  group Linkkit/external
    ../../../../../external/: ali_ca_cert.c
    ../../../../../external/mbedtls/library/: aes.c asn1parse.c base64.c bignum.c cipher.c cipher_wrap.c ctr_drbg.c debug.c entropy.c entropy_poll.c error.c md.c md_wrap.c net_sockets.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c rsa.c sha1.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_tls.c timing.c x509.c x509_crt.c
software components: CMSIS:CORE 5.1.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
